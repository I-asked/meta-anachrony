SRC_URI:remove = "file://0002-usb-modded-worker-Use-buteo-mtp-wrapper.patch"
RDEPENDS:${PN}:remove = "buteo-mtp"
