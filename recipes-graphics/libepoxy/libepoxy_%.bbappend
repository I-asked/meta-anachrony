REQUIRED_DISTRO_FEATURES:remove = "opengl"

DEPENDS:remove = "virtual/libgl"
DEPENDS:append = " virtual/libgles2"
