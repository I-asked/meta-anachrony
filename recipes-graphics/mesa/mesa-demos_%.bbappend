REQUIRED_DISTRO_FEATURES:remove = "opengl"
DEPENDS:remove = "libglu"
DEPENDS:remove = "virtual/libgl"
