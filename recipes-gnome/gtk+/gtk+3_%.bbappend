DEPENDS:pn-gtk+3:append = " libepoxy glib-2.0 cairo pango atk jpeg libpng gdk-pixbuf gdk-pixbuf-native"
