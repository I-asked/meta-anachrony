FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"
S = "${WORKDIR}"
#RDEPENDS:${PN}:remove = "psplash"
